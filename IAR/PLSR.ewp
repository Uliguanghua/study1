# IAR project PLSR.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407IG ST STM32F407IG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F40XX; USE_STDPERIPH_DRIVER; SYSTEM_SUPPORT_OS
  ICCARM.CCIncludePath2: ..\APP; ..\CMSIS; ..\DRIVERS\inc; ..\DRIVERS\src; $PROJ_DIR$; ..\DRIVERS\System\LED; ..\DRIVERS\System\sys; ..\UCOS\CONFIG; ..\UCOS\CORE; ..\UCOS\PORT; ..\DRIVERS\System\delay; ..\DRIVERS\System\UART; ..\DRIVERS\System\DMA; ..\DRIVERS\System\PWM; ..\DRIVERS\System\EXTI
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: PLSR.srec
  ILINK.IlinkOutputFile: PLSR.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APP
    ../APP/: fun.c main.c main.h system_stm32f4xx.c
  group CMSIS
    ../CMSIS/: core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h stm32f4xx.h stm32f4xx_conf.h system_stm32f4xx.h
  group DRIVERS/inc
    ../DRIVERS/inc/: misc.h stm32f4xx_adc.h stm32f4xx_can.h stm32f4xx_cec.h stm32f4xx_crc.h stm32f4xx_cryp.h stm32f4xx_dac.h stm32f4xx_dbgmcu.h stm32f4xx_dcmi.h stm32f4xx_dfsdm.h stm32f4xx_dma.h stm32f4xx_dma2d.h stm32f4xx_dsi.h stm32f4xx_exti.h stm32f4xx_flash.h stm32f4xx_flash_ramfunc.h stm32f4xx_fmpi2c.h stm32f4xx_fsmc.h stm32f4xx_gpio.h stm32f4xx_hash.h stm32f4xx_i2c.h stm32f4xx_iwdg.h stm32f4xx_lptim.h stm32f4xx_ltdc.h stm32f4xx_pwr.h stm32f4xx_qspi.h stm32f4xx_rcc.h stm32f4xx_rng.h stm32f4xx_rtc.h stm32f4xx_sai.h stm32f4xx_sdio.h stm32f4xx_spdifrx.h stm32f4xx_spi.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h stm32f4xx_wwdg.h
  group DRIVERS/src
    ../DRIVERS/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group DRIVERS/system/DELAY
    ../DRIVERS/System/delay/: delay.c delay.h
  group DRIVERS/system/DMA
    ../DRIVERS/System/DMA/: dma.c dma.h
  group DRIVERS/system/EXTI
    ../DRIVERS/System/EXTI/: exti.c exti.h
  group DRIVERS/system/LED
    ../DRIVERS/System/LED/: led.c led.h
  group DRIVERS/system/PWM
    ../DRIVERS/System/PWM/: pwm.c pwm.h
  group DRIVERS/system/SYS
    ../DRIVERS/System/sys/: sys.h
  group DRIVERS/system/USART
    ../DRIVERS/System/UART/: usart.c usart.h
  group IAR
    ./: startup_stm32f40_41xxx.s stm32f4xx_flash.icf
  group UCOS/CONFIG
    ../UCOS/CONFIG/: includes.h os_cfg.h
  group UCOS/CORE
    ../UCOS/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group UCOS/PORT
    ../UCOS/PORT/: os_cpu.h os_cpu_a.asm os_cpu_c.c
